# Keil uVision project pandent.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: M058ZAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: pandent
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=2
  c include: .\BSP_Library\M051SeriesBSP_CMSIS_v2.01.002\LibM051Series\CMSIS\CM0\CoreSupport;.\BSP_Library\M051SeriesBSP_CMSIS_v2.01.002\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;.\BSP_Library\M051SeriesBSP_CMSIS_v2.01.002\LibM051Series\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group CMSIS
    ./BSP_Library/M051SeriesBSP_CMSIS_v2.01.002/LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ./BSP_Library/M051SeriesBSP_CMSIS_v2.01.002/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ./BSP_Library/M051SeriesBSP_CMSIS_v2.01.002/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group SRC
    ./: custerm.c interrupt.c main.c misc.c module.c udp.c
